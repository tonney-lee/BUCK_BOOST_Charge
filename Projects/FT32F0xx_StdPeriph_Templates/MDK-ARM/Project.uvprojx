# Keil uVision project Project.uvprojx, settings and files
target FT32F030X (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: FT32F030C8ATx FMD
  pack: FMD.FT32F0xx_DFP.1.0.1
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: FT32F0XX +hex
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: FT32F030x6,USE_STDPERIPH_DRIVER,USE_FT32F030XX_EVAL,USE_DEFAULT_TIMEOUT_CALLBACK
  c include: ..\;..\..\..\Libraries\CMSIS\Device\FT\FT32F0xx\Include;..\..\..\Libraries\CMSIS\Include;..\..\..\Libraries\FT32F0xx_StdPeriph_Driver\inc;..\..\..\Libraries\FT32F0xx_CPAL_Driver\inc;..\..\..\Utilities\FT32_EVAL\Common;..\..\..\Utilities\FT32_EVAL\FT32F030xx_EVAL;..\..\..\MyPT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../../../Libraries/CMSIS/Device/FT/FT32F0xx/Source/Templates/arm/: startup_ft32f030x8.s
    ../: system_ft32f0xx.c
  group Usr
    ../: main.c ft32f0xx_it.c
  group StdPeriph_Driver
    ../../../Libraries/FT32F0xx_StdPeriph_Driver/src/: FT32f0xx_adc.c FT32f0xx_comp.c FT32f0xx_crc.c FT32f0xx_crs.c FT32f0xx_dac.c FT32f0xx_dbgmcu.c FT32f0xx_dma.c FT32f0xx_exti.c FT32f0xx_flash.c FT32f0xx_gpio.c FT32f0xx_i2c.c FT32f0xx_iwdg.c FT32f0xx_misc.c FT32f0xx_pwr.c FT32f0xx_rcc.c FT32f0xx_rtc.c FT32f0xx_spi.c FT32f0xx_syscfg.c FT32f0xx_tim.c FT32f0xx_usart.c FT32f0xx_wwdg.c
  group utility
    ../../../Utilities/FT32_EVAL/FT32F030XX_EVAL/: FT32F030XX_eval.c FT32F030XX_eval_lcd.c FT32F030XX_eval_i2c_ee.c
  group MyPT
    ../../../MyPT/: sem.c systick.c thread.c
  group User
    ../../../User/: my_adc.c my_io_port.c my_key.c my_timer.c my_uart.c usr.c
